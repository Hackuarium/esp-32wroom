.title KiCad schematic
U2 +3V3 /SDA /SCL GND MS5637
Q1 /IO12 Net-_J10-Pad1_ GND BSP75
U3 /SDA GND NC_01 NC_02 +3V3 /SCL NC_03 Si7020-A20
J1 +12V GND 5 / 12V
Q2 /IO13 Net-_J11-Pad1_ GND BSP75
Q3 /IO14 Net-_J12-Pad1_ GND BSP75
Q4 /IO15 Net-_J13-Pad1_ GND BSP75
J15 GND NC_04 /VCC_FTDI /RX /TX NC_05 CONN FT232RL
SW1 GND /RST RESET
J16 +12V /SCL /SDA GND +BATT GND RJ12-I2C
J17 +12V /SCL /SDA GND +BATT GND RJ12-I2C
SW2 /IO0 GND PROG
R1 +3V3 /ONE1 4.7k
D1 /MCP73831/VIN /ACT4088-50/5.0V D_Schottky
D3 /MCP73831/VIN /VCC_FTDI D_Schottky
J4 GND NC_06 +3V3 /ONE2 NC_07 Onewire
J3 GND NC_08 +3V3 /ONE1 NC_09 Onewire
J10 Net-_J10-Pad1_ Red
J11 Net-_J11-Pad1_ Green
J12 Net-_J12-Pad1_ Blue
J13 Net-_J13-Pad1_ White
J14 GND Pad
TP1 /ONE1 GND OneWire
J9 +12V +BATT +3V3 /EXT1 /EXT2 /EXT3 /EXT4 GND IO_RGBW
TP4 +3V3 GND 3.3V
TP2 /ACT4088-50/5.0V GND 5V
TP3 /ACT4088-33/VIN GND V_OUT
TP5 +BATT GND V_BAT
J2 +12V +12V
TP8 /SCL /SDA GND Test_i2C
TP7 /RX /TX GND Test_UART
C3 +3V3 GND 10uF
C4 +3V3 GND 10uF
J5 NC_10 hole
J6 NC_11 hole
J7 NC_12 hole
J8 NC_13 hole
C2 /RST GND 10uF
R4 /TX Net-_R4-Pad2_ 499
C1 GND /IO0 100nF
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ LED
R5 GND Net-_D4-Pad1_ 10k
D2 Net-_D2-Pad1_ +3V3 LED
R2 GND Net-_D2-Pad1_ 10k
R3 +3V3 /ONE2 4.7k
TP6 /ONE2 GND OneWire
U1 GND +3V3 /RST CHARGING NC_14 /ONE1 /ONE2 /EXT3 /EXT4 /EXT1 /EXT2 ADC /IO14 /IO12 GND /IO13 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 /IO15 NC_21 /IO0 NC_22 NC_23 NC_24 NC_25 Net-_D4-Pad2_ NC_26 NC_27 /SDA /RX Net-_R4-Pad2_ /SCL NC_28 GND ESP32-WROOM-32U
U4 Net-_R9-Pad1_ GND +BATT /MCP73831/VIN Net-_R8-Pad1_ MCP73831-2
R8 Net-_R8-Pad1_ GND 10k
C6 +BATT GND 10uF
R9 Net-_R9-Pad1_ CHARGING 10k
R11 CHARGING /MCP73831/VIN 10k
R7 +BATT ADC 1M
R10 ADC GND 270k
C7 ADC GND 100nF
D5 /ACT4088-33/VIN /MCP73831/VIN D_Schottky
R6 /MCP73831/VIN GND 100k
C5 /MCP73831/VIN GND 10uF
J18 GND +BATT BATT
D6 /MCP73831/VIN +BATT /ACT4088-33/VIN DMP1045U
U6 Net-_C10-Pad2_ +12V NC_29 Net-_R12-Pad2_ GND Net-_C10-Pad1_ ACT4088
C10 Net-_C10-Pad1_ Net-_C10-Pad2_ 22nF
L1 Net-_C10-Pad2_ /ACT4088-50/5.0V 4.7µH
R12 /ACT4088-50/5.0V Net-_R12-Pad2_ 49.9k
R13 GND Net-_R12-Pad2_ 9.64k
C12 /ACT4088-50/5.0V GND 22µF
C11 +12V GND 10µF
U5 Net-_C8-Pad2_ /ACT4088-33/VIN NC_30 Net-_R14-Pad2_ GND Net-_C8-Pad1_ ACT4088
C8 Net-_C8-Pad1_ Net-_C8-Pad2_ 22nF
L2 Net-_C8-Pad2_ +3V3 4.7µH
R14 +3V3 Net-_R14-Pad2_ 49.9k
R15 GND Net-_R14-Pad2_ 16.23k
C13 +3V3 GND 22µF
C9 /ACT4088-33/VIN GND 10µF
.end
